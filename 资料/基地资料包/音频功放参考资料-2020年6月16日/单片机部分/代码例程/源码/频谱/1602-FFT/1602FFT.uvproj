# Keil uVision project 1602FFT.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 1602FFT +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源代码组 1
    ./: 1602.c display.c FFT.c main.c
